# Keil uVision project C_01_GPIO_STM32F1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: C_01_GPIO_STM32F1
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ../source/: main.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
